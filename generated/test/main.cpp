
#include "protocol.h"

#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <time.h>
#include <stdio.h>






static const uint8_t test_buffer[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x19, 0x88, 0x20, 0x21, 0x4B, 0xB5, 0xDA, 0x41, 0x00, 0x01,
    0x46, 0x00, 0x00, 0x00, 0x21, 0x2C, 0x2C, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34, 0x21, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34, 0x21, 0x0A, 0x0A, 0x0A, 0x0A,
    0xFF, 0x34, 0x21, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34, 0x21, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34,
    0x21, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34, 0x21, 0x34, 0x21, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34,
    0x21, 0x34, 0x21, 0x0A, 0x0A, 0x0A, 0x0A, 0xFF, 0x34, 0x21,
};


Message m;
BytesStream s;


int main(void){

    size_t remaining = sizeof(test_buffer);

    const uint8_t *next = message_decode(
        &m,
        test_buffer,
        &remaining
    );

    if (next == NULL) {
        printf("Message decode failed\n");
        return 1;
    }



    const uint8_t *stream_end = bytes_stream_decode(
        &s,
        next,
        &remaining
    );

    if (stream_end == NULL) {
        printf("Stream decode failed\n");
        return 1;
    }

    printf("Stream length: %u\n", (unsigned)s.length);
    for (uint32_t i = 0; i < s.length; i++) {
        printf("%u  ", (unsigned)((const uint8_t *)s.content)[i]);
    }
    printf("\n");


    printf("Stream length: %u\n", (unsigned)s.length);

    return 0;
}